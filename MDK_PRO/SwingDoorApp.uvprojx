# Keil uVision project SwingDoorApp.uvprojx, settings and files
target SwingDoorApp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SwingDoorApp +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\1McuLayer\CMSIS;..\1McuLayer\STM32F4xx_StdPeriph_Driver\inc;..\2LowLayer\LED;..\3MiddleLayer\delay;..\3MiddleLayer\sys;..\2LowLayer\USART;..\4UserLayer;..\5FreeRTOS\include;..\5FreeRTOS\portable\RVDS\ARM_CM4F;..\2LowLayer\FLASH;..\2LowLayer\KEY;..\3MiddleLayer\easyflash\inc;..\2LowLayer\TIME;..\2LowLayer\FLASH\inc;..\3MiddleLayer\ini;..\3MiddleLayer\stmflash;..\3MiddleLayer\ymodem;..\3MiddleLayer\cjson;..\3MiddleLayer\malloc;..\3MiddleLayer\easylogger\inc;..\2LowLayer\BEEP;..\2LowLayer\INFRARED;..\2LowLayer\DigitalTube;..\2LowLayer\BSP;..\2LowLayer\WDG;..\2LowLayer\READER;..\2LowLayer\SUART;..\4UserLayer\Apps;..\4UserLayer\Task
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Log
    ../Log/: ModifyRecords.txt
  group UserLayer
    ../4UserLayer/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../4UserLayer/Apps/: comm.c Devinfo.c errorcode.c test.c tool.c
  group Task
    ../4UserLayer/Task/: BarCode_Task.c HandShake_Task.c Led_Task.c MotorCtrl_Task.c MsgParse_Task.c Reader_Task.c Sensor_Task.c Watchdog_Task.c
  group ComponentLayer
    ../3MiddleLayer/delay/: delay.c
    ../3MiddleLayer/sys/: sys.c
    ../3MiddleLayer/ini/: ini.c
    ../3MiddleLayer/ymodem/: ymodem.c
    ../3MiddleLayer/stmflash/: stmflash.c
    ../3MiddleLayer/cjson/: cJSON.c cJSON_Utils.c
    ../3MiddleLayer/malloc/: malloc.c
  group DriveLayer
    ../2LowLayer/BEEP/: bsp_beep.c
    ../2LowLayer/DigitalTube/: bsp_DigitalTube.c
    ../2LowLayer/FLASH/: bsp_spi_flash.c
    ../2LowLayer/INFRARED/: bsp_infrared.c
    ../2LowLayer/KEY/: bsp_key.c
    ../2LowLayer/LED/: bsp_led.c
    ../2LowLayer/TIME/: bsp_time.c
    ../2LowLayer/USART/: bsp_usart1.c bsp_usart2.c bsp_usart3.c bsp_usart4.c bsp_usart5.c bsp_rs485.c bsp_uart_fifo.c
    ../2LowLayer/BSP/: bsp.c
    ../2LowLayer/WDG/: bsp_iwdg.c
    ../2LowLayer/READER/: bsp_Wiegand.c
    ../2LowLayer/SUART/: bsp_uart.c UARTQueue.c
  group StdPeriphDriver
    ../1McuLayer/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_exti.c
  group CMSIS
    ../1McuLayer/CMSIS/: startup_stm32f40_41xxx.s
  group FreeRTOS_CORE
    ../5FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../5FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../5FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_CLI
    ../5FreeRTOS/cli/: FreeRTOS_CLI.c UARTCommandConsole.c CLI_Serial.c cmd_fun.c
  group sfud
    ../2LowLayer/FLASH/src/: sfud.c sfud_sfdp.c
    ../2LowLayer/FLASH/port/: sfud_port.c
  group EasyFlash
    ../3MiddleLayer/easyflash/src/: easyflash.c ef_utils.c ef_env.c ef_iap.c
    ../3MiddleLayer/easyflash/port/: ef_port.c
  group EasyLogger
    ../3MiddleLayer/easylogger/src/: elog.c elog_utils.c
    ../3MiddleLayer/easylogger/port/: elog_port.c
